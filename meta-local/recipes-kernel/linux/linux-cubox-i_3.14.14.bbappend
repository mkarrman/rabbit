FILESEXTRAPATHS_prepend := "${THISDIR}/linux-cubox-i:"
SRCBRANCH = "linux-linaro-lsk-v3.14-mx6"

