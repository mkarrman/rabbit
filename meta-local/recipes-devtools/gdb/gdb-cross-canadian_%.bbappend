# Enable the TUI user interface
PACKAGECONFIG_CONFARGS_remove = "--disable-tui"
PACKAGECONFIG_CONFARGS_append = " --enable-tui"
