# Package features for magicmirror

PACKAGECONFIG = "wayland webgl gles2 enchant libsecret"
