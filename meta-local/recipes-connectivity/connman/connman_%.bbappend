# Limit supported technologies for rabbit

PACKAGECONFIG_rabbit = "wifi iptables"

