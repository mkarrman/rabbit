# FUBAR in meta-networking
RDEPENDS_${PN}_remove += "wireless-regdb-static"
RDEPENDS_${PN}_append += " wireless-regdb"
